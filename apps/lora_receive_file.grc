<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_receive_file</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitrate</value></param>
<param><key>value</key><value>sf * (1 / (2**sf / bw))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>value</key><value>866.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_tap</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, bw, 10000, firdes.WIN_HAMMING, 6.67)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>-(capture_freq - target_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_sec</value></param>
<param><key>value</key><value>bw / (2**sf)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq</value></param>
<param><key>value</key><value>868.1e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>counting_cr4_sf7.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/cap.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>freq</key><value>capture_freq</value></param>
<param><key>offset</key><value>offset</value></param>
<param><key>in_samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>capture_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
